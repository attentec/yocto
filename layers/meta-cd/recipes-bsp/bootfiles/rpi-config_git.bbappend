ENABLE_UART = "1"